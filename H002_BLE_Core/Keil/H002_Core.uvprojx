# Keil uVision project H002_Core.uvprojx, settings and files
target H002_BLE_Core (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: H002_BLE_Core +hex (library)
  AfterMake: copy_lib.bat
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: keil,AM_PACKAGE_BGA,AM_PART_APOLLO3 ,AM_FREERTOS
  c include: ..\Platform\PlatformSource\CMSIS\ARM\Include;..\Platform\PlatformSource\CMSIS\AmbiqMicro\Include;..\Platform;..\Platform\PlatformSource\mcu;..\Platform\PlatformSource\mcu\hal;..\Platform\PlatformSource\mcu\regs;..\Platform\PlatformSource\utils;..\Platform\PlatformStartup;..\Drv_Layer;..\Drv_Layer\Common;..\Drv_Layer\DrvSource;..\Drv_Layer\DrvSource\Pahsource;..\Lib;..\Platform\PlatformSource;..\Platform\PlatformPorting;..\Mid_Layer\FreeRTOS;..\Mid_Layer\FreeRTOS\Source;..\Mid_Layer\FreeRTOS\Source\include;..\Mid_Layer\FreeRTOS\Source\portable\Keil\AMapollo2;..\Mid_Layer\Algorithm;..\Mid_Layer\ImageInfo;..\Mid_Layer\Common;..\Mid_Layer\MidSource;..\App_Layer\FunctionSource;..\PictureSource;..\Mid_Layer\BLE\sw\apps\app\include;..\Mid_Layer\BLE\sw\apps\app;..\Mid_Layer\BLE\sw\hci\ambiq;..\Mid_Layer\BLE\sw\profiles\uribeacon;..\Mid_Layer\BLE\sw\sec\common;..\Mid_Layer\BLE\sw\sec\include;..\Mid_Layer\BLE\sw\services;..\Mid_Layer\BLE\sw\stack\cfg;..\Mid_Layer\BLE\sw\stack\hci;..\Mid_Layer\BLE\sw\stack\include;..\Mid_Layer\BLE\ws-core\include;..\Mid_Layer\BLE\sw\hci\include;..\Mid_Layer\BLE\ws-core\sw\util;..\Mid_Layer\BLE\ws-core\sw\wsf\ambiq;..\Mid_Layer\BLE\ws-core\sw\wsf\include;..\Mid_Layer\BLE\sw\hci\ambiq\em9304;..\Mid_Layer\BLE\stack_app;..\Mid_Layer\BLE\stack_app\apps\ancs;..\Mid_Layer\BLE\stack_app\apps\m_ble;..\Mid_Layer\BLE\stack_app\profiles\ancc;..\Mid_Layer\BLE\stack_app\services;..\Mid_Layer\BLE\sw\profiles\dis;..\Mid_Layer\BLE\sw\profiles\gap;..\Mid_Layer\BLE\sw\profiles\gatt;..\Mid_Layer\BLE\stack_app\profiles\amota;..\Mid_Layer\BLE\stack_app\profiles\lowsapp;..\Mid_Layer\BLE\stack_app\apps\ble_stack;..\Module_Test;..\Debug;..\Mid_Layer\BLE\sw\hci\ambiq\apollo3;..\Mid_Layer\modules;..\Drv_Layer\DrvSource\20180521_ref_src_total_type_R2\DEMO_NRF5;..\Drv_Layer\DrvSource\20180521_ref_src_total_type_R2\PAH_MAIN;..\Drv_Layer\DrvSource\20180521_ref_src_total_type_R2\PAH8011;..\Drv_Layer\DrvSource\20180521_ref_src_total_type_R2\PAH8011\verify;..\Drv_Layer\DrvSource\20180521_ref_src_total_type_R2\PxiAlg\HR\v5421;..\Mid_Layer\scene;..\App_Layer\UIManage;..\Drv_Layer\DrvSource\20180521_ref_src_total_type_R2\PxiAlg\HRV\V203;..\Mid_Layer\store;..\Mid_Layer\pdu;..\Drv_Layer\upgrade_it7259;..\Mid_Layer\BLE\stack_app\apps\ota
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: ..\App_Layer\H002_Public.sct
  link misc: --diag_suppress=L6314,L6329
  group PlatformStartup
    ../Platform/PlatformStartup/: startup_Apollo.s
  group PlatformSource
    ../Platform/PlatformSource/mcu/hal/: am_hal_cachectrl.c am_hal_clkgen.c am_hal_flash.c am_hal_gpio.c am_hal_interrupt.c am_hal_mcuctrl.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_stimer.c am_hal_sysctrl.c am_hal_ble.c am_hal_ble_patch.c am_hal_secure_ota.c am_hal_burst.c am_hal_ctimer.c am_hal_debug.c
    ../Platform/PlatformSource/utils/: am_util_delay.c am_util_faultisr.c
  group AppSource
    ../App_Layer/FunctionSource/: main_ota.c
  group FreeRTOS
    ../Mid_Layer/FreeRTOS/: rtos.c
    ../Mid_Layer/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../Mid_Layer/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../Mid_Layer/FreeRTOS/Source/portable/Keil/AMapollo2/: port.c
  group PlatformPorting
    ../Platform/PlatformPorting/: sm_sys.c sm_flash.c sm_pwm.c sm_os.c
  group BLE
    ../Mid_Layer/BLE/ws-core/sw/util/: bda.c bstream.c calc128.c crc32.c wstr.c
    ../Mid_Layer/BLE/ws-core/sw/wsf/ambiq/: wsf_assert.c wsf_math.c wsf_os.c wsf_trace.c
    ../Mid_Layer/BLE/ws-core/sw/wsf/common/: wsf_buf.c wsf_efs.c wsf_msg.c wsf_queue.c wsf_timer.c
    ../Mid_Layer/BLE/sw/apps/app/generic/: app_db.c
    ../Mid_Layer/BLE/sw/apps/app/: app_disc.c app_main.c app_server.c app_slave.c app_slave_leg.c
    ../Mid_Layer/BLE/sw/hci/ambiq/: hci_cmd.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c
    ../Mid_Layer/BLE/sw/profiles/gatt/: gatt_main.c
    ../Mid_Layer/BLE/sw/sec/common/: sec_aes.c sec_cmac.c sec_ecc_hci.c sec_main.c
    ../Mid_Layer/BLE/sw/services/: svc_core.c svc_dis.c
    ../Mid_Layer/BLE/sw/stack/cfg/: cfg_stack.c
    ../Mid_Layer/BLE/sw/stack/hci/: hci_main.c
    ../Mid_Layer/BLE/stack_app/services/: svc_lowsapp.c svc_amotas.c
    ../Mid_Layer/BLE/stack_app/: radio_task.c
    ../Mid_Layer/BLE/projects/generic/stacklib/keil/Cortex-M4/: stacklib.lib
    ../Mid_Layer/BLE/stack_app/profiles/amota/: amotas_main.c smota_flash.c amotas_main_v2.c
    ../Mid_Layer/BLE/stack_app/profiles/lowsapp/: lowsapp_main.c
    ../Mid_Layer/BLE/sw/hci/ambiq/apollo3/: hci_drv_apollo3.c
    ../Mid_Layer/BLE/stack_app/apps/ble_stack/: BLE_Kernal.c
    ../Mid_Layer/BLE/stack_app/apps/ota/: ble_ota.c
  group Debug
    ../Debug/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group MidSource
    ../Mid_Layer/MidSource/: system_task.c mid_lcd_core.c
  group DrvSource
    ../Drv_Layer/DrvSource/: drv_nandflash_init.c drv_rgb_lcd.c
  group UIManage
    ../App_Layer/UIManage/: ui_ota_imagesrcource.c
