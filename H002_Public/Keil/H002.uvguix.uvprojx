# Keil uVision project H002.uvguix.uvprojx, settings and files
target H002_Public (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: H002_PD000_V0.0.6 +hex
  AfterMake: fromelf --bin --output bin\ Objects\H002_Public.axf
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: keil,AM_PACKAGE_BGA,AM_PART_APOLLO3 ,AM_FREERTOS
  c include: ..\Platform\PlatformSource\CMSIS\ARM\Include;..\Platform\PlatformSource\CMSIS\AmbiqMicro\Include;..\Platform;..\Platform\PlatformSource\mcu;..\Platform\PlatformSource\mcu\hal;..\Platform\PlatformSource\mcu\regs;..\Platform\PlatformSource\utils;..\Platform\PlatformStartup;..\Drv_Layer;..\Drv_Layer\Common;..\Drv_Layer\DrvSource;..\Drv_Layer\DrvSource\Pahsource;..\Lib;..\Platform\PlatformSource;..\Platform\PlatformPorting;..\Mid_Layer\FreeRTOS;..\Mid_Layer\FreeRTOS\Source;..\Mid_Layer\FreeRTOS\Source\include;..\Mid_Layer\FreeRTOS\Source\portable\Keil\AMapollo2;..\Mid_Layer\Algorithm;..\Mid_Layer\ImageInfo;..\Mid_Layer\Common;..\Mid_Layer\MidSource;..\App_Layer\FunctionSource;..\PictureSource;..\Mid_Layer\BLE\sw\apps\app\include;..\Mid_Layer\BLE\sw\apps\app;..\Mid_Layer\BLE\sw\hci\ambiq;..\Mid_Layer\BLE\sw\profiles\uribeacon;..\Mid_Layer\BLE\sw\sec\common;..\Mid_Layer\BLE\sw\sec\include;..\Mid_Layer\BLE\sw\services;..\Mid_Layer\BLE\sw\stack\cfg;..\Mid_Layer\BLE\sw\stack\hci;..\Mid_Layer\BLE\sw\stack\include;..\Mid_Layer\BLE\ws-core\include;..\Mid_Layer\BLE\sw\hci\include;..\Mid_Layer\BLE\ws-core\sw\util;..\Mid_Layer\BLE\ws-core\sw\wsf\ambiq;..\Mid_Layer\BLE\ws-core\sw\wsf\include;..\Mid_Layer\BLE\sw\hci\ambiq\em9304;..\Mid_Layer\BLE\stack_app;..\Mid_Layer\BLE\stack_app\apps\ancs;..\Mid_Layer\BLE\stack_app\apps\m_ble;..\Mid_Layer\BLE\stack_app\profiles\ancc;..\Mid_Layer\BLE\stack_app\services;..\Mid_Layer\BLE\sw\profiles\dis;..\Mid_Layer\BLE\sw\profiles\gap;..\Mid_Layer\BLE\sw\profiles\gatt;..\Mid_Layer\BLE\stack_app\profiles\amota;..\Mid_Layer\BLE\stack_app\profiles\lowsapp;..\Mid_Layer\BLE\stack_app\apps\ble_stack;..\Module_Test;..\Debug;..\Mid_Layer\BLE\sw\hci\ambiq\apollo3;..\Mid_Layer\modules;..\Drv_Layer\DrvSource\20180521_ref_src_total_type_R2\DEMO_NRF5;..\Drv_Layer\DrvSource\20180521_ref_src_total_type_R2\PAH_MAIN;..\Drv_Layer\DrvSource\20180521_ref_src_total_type_R2\PAH8011;..\Drv_Layer\DrvSource\20180521_ref_src_total_type_R2\PAH8011\verify;..\Drv_Layer\DrvSource\20180521_ref_src_total_type_R2\PxiAlg\HR\v5421;..\Mid_Layer\scene;..\App_Layer\UIManage;..\Drv_Layer\DrvSource\20180521_ref_src_total_type_R2\PxiAlg\HRV\V203;..\Mid_Layer\store;..\Drv_Layer\upgrade_it7259;..\Mid_Layer\BLE\stack_app\apps\ota;..\Drv_Layer\DrvSource\BMI160_driver-master;..\App_Layer\WindowsManage
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: ..\App_Layer\H002_Public_OTA.sct
  link misc: --diag_suppress=L6314,L6329
  group PlatformStartup
    ../Platform/PlatformStartup/: sys_setup.c
  group PlatformSource
    ../Platform/PlatformSource/mcu/hal/: am_hal_adc.c am_hal_global.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_pdm.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_wdt.c am_hal_cmdq.c
    ../Platform/PlatformSource/utils/: am_util_faultisr.c
  group DrvSource
    ../Drv_Layer/Common/: bsp_common.c
    ../Drv_Layer/DrvSource/: drv_bat.c drv_font.c drv_key.c drv_mtimer.c drv_airpress.c drv_mag.c drv_hrm.c drv_touch.c drv_motor.c drv_nandflash.c drv_bm43.c drv_gps.c drv_ntc.c drv_charger.c drv_mic.c
    ../Drv_Layer/DrvSource/BMI160_driver-master/: bmi160.c
  group MidSource
    ../Mid_Layer/MidSource/: mid_interface.h mid_scheduler.c mid_hrm.c mid_key.c mid_magnetism.c mid_pressure.c mid_rtc.c mid_uart.c ble_task.c mid_bat.c mid_front.c mid_nandflash.c mid_motor.c mid_lcd.c mid_infrared_temp.c mid_mic.c mid_wdt.c ble_db.c mid_6dof.c
    ../Mid_Layer/Common/: mid_common.c
  group scenes
    ../Mid_Layer/scene/: scene_variable.h scene_interface.h scene_variable.c scene_interface.c scene_task.c scene_sedentary.c scene_hrm.c scene_stress.c scene_abc.c scene_run.c scene_climb.c scene_swim.c scene_findphone.c scene_common.c scene_stairs.c scene_gesture.c scene_sleep.c scene_step.c scene_weather.c scene_alarm.c scene_stopwatch.c scene_countdown.c
  group store
    ../Mid_Layer/store/: store_variable.h store_interface.h store_variable.c store_interface.c store_algo.c store_part.c store_task.c store_step.c store_hrd.c store_run.c store_stress.c store_bodytemp.c store_sleep.c store_climb.c store_swim.c store_abc.c store_common.c store_pdu.c store_history.c store_sleep_record.c store_gps.c
  group AppSource
    ../App_Layer/FunctionSource/: main.c app_protocal.c app_task.c app_variable.c app_remind_manage.c app_lcd.c app_systerm.c app_time.c
  group WindowsManage
    ../App_Layer/WindowsManage/: win_main.c win_timer.c win_task.c win_store.c win_pwron.c win_datetime.c win_step.c win_heartrate.c win_stress.c win_temperature.c win_sleep.c win_abc.c win_history.c win_lock.c win_modelist.c win_run.c win_climb.c win_swim.c win_sporthistory.c win_stopwatch.c win_countdown.c win_alarm.c win_findphone.c win_set.c win_charge.c win_warn.c
  group UIManage
    ../App_Layer/UIManage/: ui_display_common.c ui_display_fontsource.c ui_display_imagesource.c ui_display_main.c ui_keyhandle_main.c ui_screen_breathtraining.c ui_screen_compass.c ui_screen_dateandtime.c ui_screen_heartrate.c ui_screen_pressure.c ui_screen_sleep.c ui_screen_step.c ui_screen_temperature.c ui_timerhandle_main.c ui_tphandle_main.c ui_screen_store.c ui_screen_modelist.c ui_screen_runingmode.c ui_screen_history.c ui_screen_climbing.c ui_screen_countdown.c ui_screen_findphone.c ui_screen_sporthistory.c ui_screen_stopwatch.c ui_screen_swim.c ui_screen_warn.c ui_display_poweron.c ui_screen_alarm.c ui_screen_other.c ui_screen_setting.c
  group Algorithm
    ../Mid_Layer/Algorithm/: algorithm_lis3dh.c algorithm_mag_degree.c algorithm_sleep.c algorithm_usual.c algorithm_gesture.c algorithm_running.c algorithm_sedentary.c algorithm_abc.c algorithm_stress.c algorithm_climbMountain.c algorithm_common.c algorithm_climb_stairs.c algorithm_swim_indoor.c
  group Lib
    ../Lib/: HFMA2Ylib.lib H002_BLE_Core.lib
  group PlatformPorting
    ../Platform/PlatformPorting/: sm_adc.c sm_gpio.c sm_pdm.c sm_spi.c sm_swi2c.c sm_hwi2c.c sm_timer.c sm_uart.c sm_wdt.c sm_swspi.c
  group PictureSource
    ../PictureSource/: app_picture_source.c app_ascii_source.c
  group BLE
    ../Mid_Layer/BLE/stack_app/apps/ancs/: ancs_main.c ancs_upload.c
    ../Mid_Layer/BLE/stack_app/apps/m_ble/: app_m_ble_profile.c
    ../Mid_Layer/BLE/stack_app/profiles/ancc/: ancc_main.c
  group Debug
    ../Debug/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group PHA8011
    ../Drv_Layer/DrvSource/20180521_ref_src_total_type_R2/DEMO_NRF5/: system_clock.c
    ../Drv_Layer/DrvSource/20180521_ref_src_total_type_R2/PAH_MAIN/: pah_hrd_function.c pah_hrv_function.c
    ../Drv_Layer/DrvSource/20180521_ref_src_total_type_R2/PAH8011/: pah_8011_internal.c pah_comm_i2c.c pah_driver_8011.c pah_driver_8011_reg_array.c
    ../Drv_Layer/DrvSource/20180521_ref_src_total_type_R2/PAH8011/verify/: pah_verify_8011.c
    ../Drv_Layer/DrvSource/20180521_ref_src_total_type_R2/PxiAlg/HR/v5421/: pah8series_motion5421_3_m4f_keil.lib
    ../Drv_Layer/DrvSource/20180521_ref_src_total_type_R2/PxiAlg/HRV/V203/: pixart_sdnn203_m4f_keil.lib
  group it7259_upgrade
    ../Drv_Layer/upgrade_it7259/: upgrade_it7259.c
